# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411VE ST STM32F411VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: D:\myTutorial\Libraries\C_C++\Embedded_C99\Microcontroller\stm32f411xx\test_lib\stm32f411ve\include; D:\myTutorial\Libraries\C_C++\Embedded_C99\Microcontroller\stm32f411xx\driver\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: test.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    source/: main.c
